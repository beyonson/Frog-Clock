# Keil uVision project OLED.uvprojx, settings and files
target STM32F1 (6160000::V6.16::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: OLED +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group app
    ./: main.c systick_time.h systick_time.c i2c_drive.c i2c_drive.h gp_drive.h gp_drive.c oled_drive.h oled_drive.c
software components: CMSIS:CORE 5.5.0, Device:Startup 1.0.0
